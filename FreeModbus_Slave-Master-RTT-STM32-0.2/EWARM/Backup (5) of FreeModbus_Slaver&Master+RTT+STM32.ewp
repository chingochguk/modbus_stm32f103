# IAR project Backup (5) of FreeModbus_Slaver&Master+RTT+STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\APP\inc; ..\BSP\inc; ..\Libaries\STM32F10x_StdPeriph_Driver\inc; ..\RT-Thread-1.1.1\include; ..\Libaries\CMSIS_EWARM\Include; ..\Libaries\CMSIS_EWARM\CM3\DeviceSupport\ST\STM32F10x; ..\FreeModbus\modbus\include; ..\FreeModbus\modbus\rtu; ..\FreeModbus\port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeModbus_Slaver&Master+RTT+STM32.srec
  ILINK.IlinkOutputFile: FreeModbus_Slaver&Master+RTT+STM32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/src/: app.c app_task.c cpuusage.c stm32f10x_it.c UserModbusSlaver.c
    ../RT-Thread-0.3.2/include/: rtthread.h
    ../APP/inc/: stm32f10x_conf.h
  group BSP
    ../RT-Thread-1.1.1/libcpu/arm/common/: backtrace.c showmem.c
    ../BSP/src/: bsp.c
    ../RT-Thread-1.1.1/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group CMSIS
    ../Libaries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FreeModbusSlaver
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/port/: port.c port.h portevent.c portserial.c porttimer.c
  group RT-Thread Kernel
    ../RT-Thread-1.1.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group StdPeriph_Driver
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libaries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
