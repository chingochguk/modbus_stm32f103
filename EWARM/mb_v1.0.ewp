# IAR project mb_v1.0.ewp, settings and files
configuration mb_v1.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../FreeModbus; ../FreeModbus/modbus; ../FreeModbus/modbus/rtu; ../FreeModbus/modbus/ascii; ../FreeModbus/modbus/tcp; ../FreeModbus/modbus/functions; ../FreeModbus/modbus/include; ../FreeModbus/port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: mb_v1.0.hex
  ILINK.IlinkOutputFile: mb_v1.0.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: adc.c flash.c freertos.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c tim.c usart.c main.c gpio.c adc.c freertos.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c
    ../FreeModbus/: UserModbusSlaver.c
  group Application/User/Modbus
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/port/: portevent.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_rcc.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s port.c portasm.s
